# Repository shortcircuitrobotics/eagle-pcbs-2012

## EAGLE design main_board.brd

Parts:
0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15: TSOP1740; TSOP17XX
3.3V_LED, 3.7V_EMPTY, 3.7V_OK, 5V_LED, 14.8V_EMPTY, 14.8V_OK: LEDSMT1206; 1206
3.3V_UART, 3.3V_UART1, 3.3V_UART2: PINHD-1X6; 1X06
3.7V_IN, 14.8V_IN: MSTBA2
C1, C5, C10, C12, C41, C42, C45, C46: 100nF; C1206
C2, C3, C11: 100nF; C0805
C4, C9, C18, C20, C22, C24, C26, C29, C31, C33, C35, C37, C39, C49, C51, C53: 4.7µF; C1206
C6: C-EUC1206; C1206
C7: 10n; C1206
C8, C17, C19, C21, C23, C25, C27, C28, C30, C32, C34, C36, C38, C40, C50, C52: 1µF; C1206
C13: 10nF; C1206
C14: 22nF; C1206
C15: 4.7nF; C1206
C16: 1u; C1206
C43, C44, C47, C48: 47µ; E2,5-6
CON_MOUSE: ML6
DIGILENT_JTAG: PINHD-1X6; 1X06
GND_A: PINHD-1X1; 1X01
GND_B: PINHD-1X1; 1X01
GND_C: PINHD-1X1; 1X01
GND_D: PINHD-1X1; 1X01
GND_E: PINHD-1X1; 1X01
IC2: LM567N; DIL08
IC4: 4050D; SO16
IC5: ATMEGA644-20PU; DIL40
IC6, IC8: 4051D; SO16
IC7: AD8655R; SO8
IC9: TINY24/44/84-SSU; SOIC14
IC10, IC11: MEGA48/88/168-PU; DIL28-3
J1: 22-27-2041-04; 6410-04
JP1, JP4: PINHD-1X1; 1X01
JP2: PINHD-1X3; 1X03
JP3, JP14: AVR-ISP-6; ML6
K2: 4052; F4052
KICKER: MSTBA2
LB_DIODE: 22-27-2021-02; 6410-02
LB_LED: 22-27-2021-02; 6410-02
MA: PINHD-1X3; 1X03
MM: PINHD-1X3; 1X03
MS: PINHD-1X3; 1X03
M_AI: LEDSMT1206; 1206
M_MOTOR: LEDSMT1206; 1206
M_SENSOR: LEDSMT1206; 1206
PB_RESET: 10-XX; B3F-10XX; MPN B3F-1000
Q2: MOSFET-NCHANNELSMD; SOT23-3
QG1: CRYSTAL_RES-XO53; XO53
R1, R3, R5, R7, R9, R11, R14, R16, R18, R20, R22, R24, R28, R53, R55, R57: 100; M1206
R2, R4, R6, R8, R10, R12, R13, R15, R17, R19, R21, R23, R27, R52, R54, R56: 100k; M1206
R25, R62, R66, R67: R-EU_R1206; R1206
R26, R33, R42, R51: 10k; R1206
R29: > 50; 0207/10
R30, R32, R41, R46: 100k; R1206
R31, R68, R69: 4.7k; R1206
R34, R35: R-EU_M1206; M1206
R36, R65: 470; R1206
R37, R40, R45: 1k; R1206
R38: 390k; R1206
R39: 130k; R1206
R43, R64: 470k; R1206
R44: 30k; R1206
R47, R48, R49, R50: 220; R1206
R58, R59, R60, R61: 330; R1206
R63: 270k; R1206
RA: PINHD-1X3; 1X03
RM: PINHD-1X3; 1X03
RS: PINHD-1X3; 1X03
RST: PINHD-1X2; 1X02
S1, S2: M9040P
SENSOR_LED: LEDSMT1206; 1206
SV1, SV4: ML14
SV2: ML10
SV5: ML20
U1: XC9572VQ44; VQ44
U$1, U$2: IRF7416; SO8-2
U$3: IRF7413; SO8-2
U$4, U$5, U$6, U$7: SCR_MOTORDRIVERSCR_MOTORDRIVER; SCR_MOTORDRIVER
U$8, U$9: PO2120; REG1X04
U$10: 74HC00; SO14

Connections:
+5V: 5V_LED.A, C16.1, C45.1, C48.+, IC2.4 (V+), IC6.16 (VCC), IC7.7 (+VS), IC8.16 (VCC), R34.2, SV1.1, SV2.2, SV4.1, U$1.1 (S), U$1.2 (S1), U$1.3 (S2), U$9.4 (VO)
+15V: K2.1, K2.S1 (S), R43.2, S1.2, U$4.R1P1 (VCC_MOTOR1), U$4.R1P2 (VCC_MOTOR2), U$5.R1P1 (VCC_MOTOR1), U$5.R1P2 (VCC_MOTOR2), U$6.R1P1 (VCC_MOTOR1), U$6.R1P2 (VCC_MOTOR2), U$7.R1P1 (VCC_MOTOR1), U$7.R1P2 (VCC_MOTOR2)
A0_LCD: IC5.19 (PCINT29/OC1A_PD5), SV5.5
BOTTOM: IC5.25 (PCINT19/TMS_PC3), SV5.16
BUS_RESET: JP3.5, RA.3, RM.3, RS.3, RST.2
CTS_BLUETOOTH: IC5.16 (PCINT26/INT0_PD2), SV5.6
ENTER: IC5.22 (PCINT16/SCL_PC0), SV5.10
FJKSABFJSD1: IC9.1 (VCC), JP14.5, R38.2, R46.2, R51.1, S2.2, U$2.1 (S), U$2.2 (S1), U$2.3 (S2)
GND: 0.GND, 1.GND, 2.GND, 3.GND, 3.3V_UART.1, 3.3V_UART1.1, 3.3V_UART2.1, 3.7V_EMPTY.C, 3.7V_IN.2, 3.7V_OK.C, 4.GND, 5.GND, 6.GND, 7.GND, 8.GND, 9.GND, 10.GND, 11.GND, 12.GND, 13.GND, 14.GND, 14.8V_EMPTY.C, 14.8V_IN.2, 14.8V_OK.C, 15.GND, C1.2, C2.1, C3.2, C4.2, C5.1, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.-, C44.-, C45.2, C46.2, C47.-, C48.-, C49.2, C50.2, C51.2, C52.2, C53.2, CON_MOUSE.1, DIGILENT_JTAG.5, GND_A.1, GND_B.1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
IR_30_F: C6.1, C7.2, IC7.6 (OUT), R30.2
JTAG_TCK: DIGILENT_JTAG.4, U1.11 (TCK)
JTAG_TDI: DIGILENT_JTAG.2, U1.9 (TDI)
JTAG_TDO: DIGILENT_JTAG.3, U1.24 (TDO)
JTAG_TMS: DIGILENT_JTAG.1, U1.10 (TMS)
KICKER_ON: IC5.34 (PCINT6/ADC6_PA6), R33.1
LB_IN: IC2.8 (Q), IC5.18 (PCINT28/OC1B_PD4), R42.1
LB_PWM: IC5.4 (PCINT11/OC0A/AIN1_PB3), R40.1
LCD_RST: IC5.5 (PCINT12/OC0B/SS_PB4), SV5.3
LEFT: IC5.24 (PCINT18/TCK_PC2), SV5.14
MA_CS: IC10.23 (PC0(ADC0/PCINT8)), U$4.R2P7 (CS/-)
MA_DIAG: U$10.3 (O)
MA_DIAG_A: U$4.R2P4 (DIAG_A/-), U$10.2 (I1)
MA_DIAG_B: U$4.R2P5 (DIAG_B/-), U$10.1 (I0)
MA_EN: IC10.12 (PD6(AIN0/OC0A/PCINT22)), U$4.R2P6 (EN)
MA_HALL_A: SV1.12, U1.3 (IO1-17), U$4.R1P4 (HALL_A)
MA_HALL_B: SV1.8, U1.2 (IO1-15), U$4.R1P6 (HALL_B)
MA_HALL_C: SV1.4, U1.1 (IO1-14/GCK3), U$4.R1P8 (HALL_C)
MA_IN_A: IC10.14 (PB0(ICP1/CLKO/PCINT0)), U$4.R2P2 (IN_A/FWD_REV)
MA_IN_B: IC10.15 (PB1(OC1A/PCINT1)), U$4.R2P3 (IN_B/BREAK)
MA_SPEED: U1.20 (IO4-5), U$4.R2P9 (SPEED)
MA_VREF: U$4.R2P8 (-/VREF)
MB_CS: IC10.24 (PC1(ADC1/PCINT9)), U$6.R2P7 (CS/-)
MB_DIAG: U$10.6 (O)
MB_DIAG_A: U$6.R2P4 (DIAG_A/-), U$10.5 (I1)
MB_DIAG_B: U$6.R2P5 (DIAG_B/-), U$10.4 (I0)
MB_EN: IC10.11 (PD5(T1/OC0B/PCINT21)), U$6.R2P6 (EN)
MB_HALL_A: SV1.5, U1.41 (IO1-6), U$6.R1P4 (HALL_A)
MB_HALL_B: SV1.9, U1.40 (IO1-5), U$6.R1P6 (HALL_B)
MB_HALL_C: SV1.13, U1.39 (IO1-2), U$6.R1P8 (HALL_C)
MB_IN_A: IC10.4 (PD2(INT0/PCINT18)), U$6.R2P2 (IN_A/FWD_REV)
MB_IN_B: IC10.26 (PC3(ADC3/PCINT11)), U$6.R2P3 (IN_B/BREAK)
MB_SPEED: U1.21 (IO4-8), U$6.R2P9 (SPEED)
MB_VREF: U$6.R2P8 (-/VREF)
MC_CS: IC10.25 (PC2(ADC2/PCINT10)), U$5.R2P7 (CS/-)
MC_DIAG: U$10.8 (O)
MC_DIAG_A: U$5.R2P4 (DIAG_A/-), U$10.10 (I1)
MC_DIAG_B: U$5.R2P5 (DIAG_B/-), U$10.9 (I0)
MC_EN: IC10.5 (PD3(INT1/OC2B/PCINT19)), U$5.R2P6 (EN)
MC_HALL_A: SV4.12, U1.38 (IO2-17), U$5.R1P4 (HALL_A)
MC_HALL_B: SV4.8, U1.37 (IO2-15), U$5.R1P6 (HALL_B)
MC_HALL_C: SV4.4, U1.34 (IO2-11/GTS2), U$5.R1P8 (HALL_C)
MC_IN_A: IC10.6 (PD4(T0/XCK/PCINT20)), U$5.R2P2 (IN_A/FWD_REV)
MC_IN_B: IC10.13 (PD7(AIN1/PCINT23)), U$5.R2P3 (IN_B/BREAK)
MC_SPEED: U1.22 (IO4-11), U$5.R2P9 (SPEED)
MC_VREF: U$5.R2P8 (-/VREF)
MD_CS: IC5.37 (PCINT3/ADC3_PA3), U$7.R2P7 (CS/-)
MD_DIAG: IC5.38 (PCINT2/ADC2_PA2), U$10.11 (O)
MD_DIAG_A: U$7.R2P4 (DIAG_A/-), U$10.13 (I1)
MD_DIAG_B: U$7.R2P5 (DIAG_B/-), U$10.12 (I0)
MD_EN: IC5.21 (PCINT31/OC2A_PD7), U$7.R2P6 (EN)
MD_HALL_A: SV4.5, U1.32 (IO2-8), U$7.R1P4 (HALL_A)
MD_HALL_B: SV4.9, U1.31 (IO2-6), U$7.R1P6 (HALL_B)
MD_HALL_C: SV4.13, U1.30 (IO2-5), U$7.R1P8 (HALL_C)
MD_IN_A: IC5.40 (PCINT0/ADC0_PA0), U$7.R2P2 (IN_A/FWD_REV)
MD_IN_B: IC5.39 (PCINT1/ADC1_PA1), U$7.R2P3 (IN_B/BREAK)
MD_SPEED: U$7.R2P9 (SPEED)
MD_VREF: IC5.20 (PCINT30/OC2B/ICP_PD6), U$7.R2P8 (-/VREF)
MISO: CON_MOUSE.6, IC5.7 (PCINT14/MISO_PB6), IC10.18 (PB4(MISO/PCINT4)), IC11.18 (PB4(MISO/PCINT4)), JP3.1, U1.18 (IO3-16)
MOSI: CON_MOUSE.3, MA.1, MM.1, MS.1, SV5.13, U1.14 (IO3-15)
MOSI_AI: IC4.3 (I), IC5.6 (PCINT13/MOSI_PB5), MA.2
MOSI_MOTOR: IC4.7 (I), IC10.17 (PB3(MOSI/OC2A/PCINT3)), MM.2
MOSI_SENSOR: IC4.5 (I), IC11.17 (PB3(MOSI/OC2A/PCINT3)), MS.2
MUX1-INH: IC6.6 (INH), IC11.12 (PD6(AIN0/OC0A/PCINT22))
MUX2-EN: IC11.13 (PD7(AIN1/PCINT23))
MUX2-INH: IC8.6 (INH)
MUX-A: IC6.11 (A), IC8.11 (A), IC11.24 (PC1(ADC1/PCINT9))
MUX-B: IC6.10 (B), IC8.10 (B), IC11.25 (PC2(ADC2/PCINT10))
MUX-C: IC6.9 (C), IC8.9 (C), IC11.26 (PC3(ADC3/PCINT11))
MUX_OUT: IC11.23 (PC0(ADC0/PCINT8)), R63.2, R64.1
unnamed: QG1.4 (CON), R25.1
unnamed: JP3.4, MA.3, MM.3, MS.3
unnamed: IC10.10 (PB7(XTAL2/TOSC2/PCINT7)), JP1.1, R61.2
unnamed: 0.OUT, R13.1
unnamed: LB_LED.2, R29.2
unnamed: LB_LED.1, Q2.3 (D)
unnamed: 0.V+, C4.1, R1.1
unnamed: Q2.1 (G), R40.2, R41.2
unnamed: C6.2, IC7.2 (IN-), LB_DIODE.1, R30.1
unnamed: 3.7V_IN.1, S2.1 (O)
unnamed: C7.1, IC2.3 (IN)
unnamed: C13.2, IC2.6 (CT), R31.2
unnamed: IC2.5 (RT), R31.1
unnamed: C15.2, IC2.2 (LFIL)
unnamed: C14.1, IC2.1 (OFIL)
unnamed: R66.2, U$9.1 (SHDN)
unnamed: 1.V+, C9.1, R3.1
unnamed: 1.OUT, R2.1
unnamed: 2.V+, C18.1, R5.1
unnamed: 2.OUT, R4.1
unnamed: 3.V+, C20.1, R7.1
unnamed: 3.OUT, R6.1
unnamed: 4.V+, C22.1, R9.1
unnamed: 4.OUT, R8.1
unnamed: 5.V+, C24.1, R11.1
unnamed: 5.OUT, R10.1
unnamed: 6.V+, C26.1, R14.1
unnamed: 6.OUT, R12.1
unnamed: 7.V+, C29.1, R16.1
unnamed: 7.OUT, R15.1
unnamed: 8.V+, C31.1, R18.1
unnamed: 8.OUT, R17.1
unnamed: 9.V+, C33.1, R20.1
unnamed: 9.OUT, R19.1
unnamed: 10.V+, C35.1, R22.1
unnamed: 10.OUT, R21.1
unnamed: 11.V+, C37.1, R24.1
unnamed: 11.OUT, R23.1
unnamed: 12.V+, C39.1, R28.1
unnamed: 14.8V_IN.1, S1.1 (O)
unnamed: 12.OUT, R27.1
unnamed: 13.V+, C49.1, R53.1
unnamed: 13.OUT, R52.1
unnamed: 14.V+, C51.1, R55.1
unnamed: 14.OUT, R54.1
unnamed: 15.V+, C53.1, R57.1
unnamed: 15.OUT, R56.1
unnamed: R32.2, R33.2, U$3.4 (G)
unnamed: M_AI.A, R58.1
unnamed: IC9.4 ((PCINT11/RESET/DW)PB3), JP14.2, R51.2
unnamed: R34.1, R35.1, U$1.4 (G)
unnamed: 3.3V_LED.C, R36.1
unnamed: 5V_LED.C, R37.1
unnamed: IC9.13 ((PCINT0/AREF/ADC0)PA0), R38.1, R39.2
unnamed: IC9.8 ((PCINT5/OC1B/MISO/DO/ADC5)PA5), JP14.6
unnamed: IC9.9 ((PCINT4/T1/SCL/USCK/ADC4)PA4), JP14.4
unnamed: IC9.7 ((PCINT6/OC1A/SDA/MOSI/ADC6)PA6), JP14.3
unnamed: IC9.12 ((PCINT1/AIN0/ADC1)PA1), R43.1, R44.2
unnamed: C42.1, C43.+, C46.1, C47.+, U$2.5 (D3), U$2.6 (D2), U$2.7 (D1), U$2.8 (D), U$8.2 (VI), U$9.2 (VI)
unnamed: IC6.3 (X), IC8.3 (X), R63.1
unnamed: IC9.2 ((PCINT8/XTAL1/CLKI)PB0), R48.2
unnamed: IC9.3 ((PCINT9/XTAL2)PB1), R47.2
unnamed: 14.8V_OK.A, R48.1
unnamed: R45.2, R46.1, U$2.4 (G)
unnamed: IC9.5 ((PCINT10/INT0/OC0A/CKOUT)PB2), R45.1
unnamed: IC9.10 ((PCINT3/T0/ADC3)PA3), R49.2
unnamed: IC9.11 ((PCINT2/AIN1/ADC2)PA2), R50.2
unnamed: 14.8V_EMPTY.A, R47.1
unnamed: 3.7V_EMPTY.A, R49.1
unnamed: 3.7V_OK.A, R50.1
unnamed: IC4.2 (O), R58.2
unnamed: M_SENSOR.A, R59.1
unnamed: M_MOTOR.A, R60.1
unnamed: IC4.4 (O), R59.2
unnamed: IC4.6 (O), R60.2
unnamed: 3.3V_UART.5, IC11.3 (PD1(TXD/PCINT17))
unnamed: K2.P1, KICKER.1
unnamed: SV4.14, U$5.R1P3 (MOTOR_+/MOTOR_A)
unnamed: K2.2, U$3.5 (D3), U$3.6 (D2), U$3.7 (D1), U$3.8 (D0)
unnamed: 3.3V_UART.4, IC11.2 (PD0(RXD/PCINT16))
unnamed: SV4.10, U$5.R1P5 (-/MOTOR_B)
unnamed: 3.3V_UART1.5, IC10.3 (PD1(TXD/PCINT17))
unnamed: SV4.6, U$5.R1P7 (MOTOR_-/MOTOR_C)
unnamed: R66.1, R67.2
unnamed: 3.3V_UART1.4, IC10.2 (PD0(RXD/PCINT16))
unnamed: SV4.3, U$7.R1P3 (MOTOR_+/MOTOR_A)
unnamed: SV1.14, U$4.R1P3 (MOTOR_+/MOTOR_A)
unnamed: SV4.7, U$7.R1P5 (-/MOTOR_B)
unnamed: SV4.11, U$7.R1P7 (MOTOR_-/MOTOR_C)
unnamed: R61.1, SENSOR_LED.A
unnamed: JP2.1, U1.29 (IO2-2)
unnamed: JP2.2, U1.28 (IO4-17)
unnamed: SV1.10, U$4.R1P5 (-/MOTOR_B)
unnamed: JP2.3, U1.27 (IO4-15)
unnamed: SV1.6, U$4.R1P7 (MOTOR_-/MOTOR_C)
unnamed: R62.2, U$8.1 (SHDN)
unnamed: R62.1, R65.2
unnamed: SV1.3, U$6.R1P3 (MOTOR_+/MOTOR_A)
unnamed: SV1.7, U$6.R1P5 (-/MOTOR_B)
unnamed: SV1.11, U$6.R1P7 (MOTOR_-/MOTOR_C)
unnamed: IC5.35 (PCINT5/ADC5_PA5), JP4.1
RESET_AI: IC5.9 (!RESET), RA.2
RESET_COM: C12.2, PB_RESET.1 (S), PB_RESET.2 (S1), R26.2, RA.1, RM.1, RS.1, RST.1, SV5.15, U1.33 (IO2-9/GSR)
RESET_MOTOR: IC10.1 (PC6(/RESET/PCINT14)), RM.2
RESET_SENSOR: IC11.1 (PC6(/RESET/PCINT14)), RS.2
RETURN: IC5.23 (PCINT17/SDA_PC1), SV5.12
RIGHT: IC5.26 (PCINT20/TDO_PC4), SV5.18
RTS_BLUETOOTH: IC5.17 (PCINT27/INT1_PD3), SV5.8
RX_BLUETOOTH: 3.3V_UART2.4, IC5.14 (PCINT24/RXD0_PD0), SV5.2
SCK: CON_MOUSE.4, IC5.8 (PCINT15/SCK_PB7), IC10.19 (PB5(SCK/PCINT5)), IC11.19 (PB5(SCK/PCINT5)), JP3.3, SV5.1, U1.13 (IO3-14)
SCL: IC10.28 (PC5(ADC5/SCLPCINT13)), J1.1, R69.1, SV5.9
SDA: IC10.27 (PC4(ADC4/SDA/PCINT12)), J1.2, R68.2, SV5.11
SS_CPLD: IC5.2 (PCINT9/CLKO/T1_PB1), U1.12 (IO3-11)
SS_LCD: IC5.3 (PCINT10/INT2/AIN0_PB2), SV5.7
SS_MOTOR: IC5.1 (PCINT8/XCK0/T0_PB0), IC10.16 (PB2(SS/OC1B/PCINT2))
SS_MOUSE_SENSOR: CON_MOUSE.2, IC5.36 (PCINT4/ADC4_PA4)
SS_SENSOR: IC5.33 (PCINT7/ADC7_PA7), IC11.16 (PB2(SS/OC1B/PCINT2))
SYS_CLK: IC5.13 (XTAL1), IC10.9 (PB6(XTAL1/TOSC1/PCINT6)), IC11.9 (PB6(XTAL1/TOSC1/PCINT6)), QG1.2 (OUT), U1.43 (IO1-9/GCK1)
TOP: IC5.27 (PCINT21/TDI_PC5), SV5.20
TSOP0: C28.1, IC6.12 (X3), R13.2
TSOP1: C8.1, IC6.2 (X6), R2.2
TSOP2: C17.1, IC6.4 (X7), R4.2
TSOP3: C19.1, IC6.1 (X4), R6.2
TSOP4: C21.1, IC6.15 (X2), R8.2
TSOP5: C23.1, IC8.5 (X5), R10.2
TSOP6: C25.1, IC8.4 (X7), R12.2
TSOP7: C27.1, IC8.2 (X6), R15.2
TSOP8: C30.1, IC8.1 (X4), R17.2
TSOP9: C32.1, IC8.12 (X3), R19.2
TSOP10: C34.1, IC8.15 (X2), R21.2
TSOP11: C36.1, IC8.14 (X1), R23.2
TSOP12: C38.1, IC8.13 (X0), R27.2
TSOP13: C40.1, IC6.13 (X0), R52.2
TSOP14: C50.1, IC6.14 (X1), R54.2
TSOP15: C52.1, IC6.5 (X5), R56.2
TSOP_ON_OFF: IC11.10 (PB7(XTAL2/TOSC2/PCINT7)), R35.2
TX_BLUETOOTH: 3.3V_UART2.5, IC5.15 (PCINT25/TXD0_PD1), SV5.4
US_BACK_ECHO: IC11.27 (PC4(ADC4/SDA/PCINT12)), SV2.5
US_BACK_TRIG: IC11.11 (PD5(T1/OC0B/PCINT21)), SV2.10
US_FRONT_ECHO: IC11.14 (PB0(ICP1/CLKO/PCINT0)), SV2.9
US_FRONT_TRIG: IC11.5 (PD3(INT1/OC2B/PCINT19)), SV2.6
US_LEFT_ECHO: IC11.28 (PC5(ADC5/SCLPCINT13)), SV2.3
US_LEFT_TRIG: IC11.6 (PD4(T0/XCK/PCINT20)), SV2.8
US_RIGHT_ECHO: IC11.15 (PB1(OC1A/PCINT1)), SV2.7
US_RIGHT_TRIG: IC11.4 (PD2(INT0/PCINT18)), SV2.4
VCC: 3.3V_LED.A, C1.1, C2.2, C3.1, C5.2, C10.1, C11.1, C41.1, C44.+, CON_MOUSE.5, DIGILENT_JTAG.6, IC4.1 (VDD), IC5.10 (VCC), IC5.30 (AVCC), IC5.32 (AREF), IC10.7 (VCC), IC10.20 (AVCC), IC10.21 (AREF), IC11.7 (VCC), IC11.20 (AVCC), IC11.21 (AREF), J1.3, JP3.2, QG1.1 (VDD), R25.2, R26.1, R29.1, R42.2, R68.1, R69.2, SV5.19, U1.15 (VCCINT1), U1.26 (VCCIO), U1.35 (VCCINT2), U$4.R2P1 (VCC_LOCIG), U$5.R2P1 (VCC_LOCIG), U$6.R2P1 (VCC_LOCIG), U$7.R2P1 (VCC_LOCIG), U$8.4 (VO), U$10.14 (PWR)
VTSOP: R1.2, R3.2, R5.2, R7.2, R9.2, R11.2, R14.2, R16.2, R18.2, R20.2, R22.2, R24.2, R28.2, R53.2, R55.2, R57.2, U$1.5 (D3), U$1.6 (D2), U$1.7 (D1), U$1.8 (D)

Notes on the sheet:
Ball Sensor
atMegas
Light Barrier
TSOPs
Analog MUX
to Interface Board
Motor Control
Sensor
Kicker
Battery Management
Max Voltage is 4.2V
Need 3:1 Voltage Divider
Max Voltage is 16.8V
Need 16:1 Voltage Divider
f = 1/(4.7k*10nF)
= 21kHZ
pullup
GlobalCLK
Motor D(ribbler) is connected to AI
Attention: Wrong Connector Orientation
Spannungsteiler HIGH=3,18
(470/(470+270))*5V = 3,18V

Board: 2 copper layers, 201.2 x 155.4 mm, 206 parts (53 on the bottom side), 217 nets.

Notices in the files:
parts and their libraries:
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
irf-2: Copyright & License
This library is licensed under the General Public License, Version 2.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
