# Repository shortcircuitrobotics/eagle-pcbs-2012 (continued)

## EAGLE design motor_adapter_right.brd (continued)

Board: 2 copper layers, 83.4 x 93.6 mm, 7 parts (1 on the bottom side), 14 nets.

## EAGLE design motor_adapter_left.brd

Parts:
R1: R-EU_R1206; R1206
R2, R3, R4: 10k; R1206
SV2: ML6
SV4: ML10
SV7: ML14
X1, X2: MSTBA2

Connections:
+5V: R2.2, R3.2, R4.1, SV2.4, SV4.4, SV7.1
GND: R1.1, SV2.3, SV4.5, SV7.2
MOTOR_B_+: SV2.2, SV7.14
MOTOR_B_-: SV2.1, SV7.6
MOTOR_B_CHANNEL_A: SV2.6, SV7.12
MOTOR_B_CHANNEL_B: SV2.5, SV7.4
MOTOR_D_HALL_A: R2.1, SV4.6, SV7.5
MOTOR_D_HALL_B: R3.1, SV4.7, SV7.9
MOTOR_D_HALL_C: R4.2, SV4.3, SV7.13
MOTOR_D_PHASE_A: SV4.8, SV7.3
MOTOR_D_PHASE_B: SV4.2, SV7.7
MOTOR_D_PHASE_C: SV4.1, SV7.11
unnamed: X1.1, X2.1
unnamed: X1.2, X2.2
unnamed: R1.2, SV7.8

Board: 2 copper layers, 83.4 x 93.6 mm, 9 parts (1 on the bottom side), 15 nets.

## Commit log

2012-08-30 Added Compass PCB
2012-08-30 Added EC (Brushless) Motor Driver PCB
2012-08-30 Interface US Board: added brd and sch
2012-08-30 Main Board: added brd and sch
2012-08-30 Motor Adapter (Left): added brd and sch
2012-08-30 Motor Adapter (Right): added brd and sch
2012-08-30 (Brushed) Motor Board: added brd and sch
2012-08-30 Added initial .gitignore for EAGLE backup files
2012-08-30 ShortCircuitRobotics Library: added
2012-08-30 InterfaceUSBoard: change resistor value
2012-08-30 Revert "InterfaceUSBoard: change resistor value" change was not needed
    This reverts commit 6388b83db6797b02bafabf1e9fd2be2e5c524c07.
2012-09-03 Main: Changed MUX-EN to MUX-INH. This pin should have been called INHIBIT in the first place because it is LOW ACTIVE!!!!!
2012-09-03 TSOP Amplifier: added inital TSOP Amplifier Design.
    The TSOP Amplifier is designed to take a voltage in the range of
    1.4V - 3.2V and amplify it to a range of 0 - 3.3V, the
    range of our ADC.
2012-09-07 ec_motor_board: necessary pullups to 3.3v connected to hall sensors leiton.dru: added for drc with leiton values
2012-09-07 ec_motor_board: added an 0 ohm resistor which can connect vref to vcc to disable power regulation
2012-09-15 SCR Library: TSOP22xx added
2012-09-24 TSOP: added brd and sch file for new tsop platine with TSOP2240
2012-09-27 TSOP: set TSOPs to the right position and started to wire low pass filters
2012-09-30 TSOP: finished TSOP.sch and TSOP.brd TSOP data wires were connected with wrong TSOPS
2012-10-06 TSOP: cutting unneeded stuff off
2012-10-07 SCR-lib: changed IRF Mosfet Symbols
    They now feature only one source and one drain pin. This
    makes use of eagle 6 where you can connect one pin on the
    schematic to several pins on the footprint.
2012-11-14 MainBoard: Fixed Motor Controller Connections Moved them to the lower layer.
2012-11-17 MainBoard: replaced old version of Kevin with new version of Christoph moved Light Barrier connections to bottom layer
2012-11-18 ShortCircuitLbr: 74HC00D in SO14 Package added MainBoard: replaced wrong nand-gate package (for DIAG Pins) with 74HC00D SO14
