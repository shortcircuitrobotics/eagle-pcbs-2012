# Repository shortcircuitrobotics/eagle-pcbs-2012 (continued)

## EAGLE design tsop.brd

Parts:
22_0, 22_1, 22_2, 22_3, 22_4, 22_5, 22_6, 22_7, 22_8, 22_9, 22_10, 22_11, 22_12, 22_13, 22_14, 22_15, 22_16, 22_17, 22_18, 22_19, 22_20, 22_21, 22_22, 22_23: TSOP2240; TSOP22XX
C1, C3, C6, C8, C10, C12, C14, C16, C18, C20, C22, C24, C26, C28, C29, C31, C33, C35, C37, C39, C41, C43, C45, C47: 1µF; C1206
C2, C4, C5, C7, C9, C11, C13, C15, C17, C19, C21, C23, C25, C27, C30, C32, C34, C36, C38, C40, C42, C44, C46, C48: 4.7µF; C1206
C65, C66: 100nF; C1206
IC1, IC2, IC3: 4051D; SO16
IC5: MEGA48/88/168-PU; DIL28-3
JP1: AVR-ISP-6; ML6
JP2: PINHD-1X3; 1X03
JP3: PINHD-1X6; 1X06
JP4: PINHD-1X4; 1X04
JP5: PINHD-1X1; 1X01
PB_RESET: 10-XX; B3F-10XX; MPN B3F-1000
QG1: CRYSTAL_RES-XO53; XO53
R1, R3, R5, R7, R9, R11, R14, R16, R18, R20, R22, R24, R26, R28, R30, R32, R34, R36, R38, R40, R42, R44, R46, R48: 100; M1206
R2, R4, R6, R8, R10, R12, R13, R15, R17, R19, R21, R23, R25, R27, R29, R31, R33, R35, R37, R39, R41, R43, R45, R47, R69, R70, R71, R72: 100k; M1206
R65: R-EU_R1206; R1206
R66: 10k; R1206
R67: 1M; M1206
R68: 0; M1206
R73, R74, R75, R76: R-EU_M1206; M1206
R77, R78: 4.7k; R1206
R79: 330; R1206
SPI_CON: ML6
TSOP_LED: LEDSMT1206; 1206
U$1, U$2: IRF7104; SO8-2

Connections:
GND: 22_0.GND, 22_1.GND, 22_2.GND, 22_3.GND, 22_4.GND, 22_5.GND, 22_6.GND, 22_7.GND, 22_8.GND, 22_9.GND, 22_10.GND, 22_11.GND, 22_12.GND, 22_13.GND, 22_14.GND, 22_15.GND, 22_16.GND, 22_17.GND, 22_18.GND, 22_19.GND, 22_20.GND, 22_21.GND, 22_22.GND, 22_23.GND, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C65.1, C66.2, IC1.7 (VEE), IC1.8 (GND), IC2.7 (VEE), IC2.8 (GND), IC3.7 (VEE), IC3.8 (GND)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
MISO: IC5.18 (PB4(MISO/PCINT4)), JP1.1, SPI_CON.6
MUX_A: IC1.11 (A), IC2.11 (A), IC3.11 (A), IC5.24 (PC1(ADC1/PCINT9))
MUX_B: IC1.10 (B), IC2.10 (B), IC3.10 (B), IC5.25 (PC2(ADC2/PCINT10))
MUX_C: IC1.9 (C), IC2.9 (C), IC3.9 (C), IC5.26 (PC3(ADC3/PCINT11))
MUX_INH_0: IC1.6 (INH), IC5.4 (PD2(INT0/PCINT18))
MUX_INH_1: IC2.6 (INH), IC5.5 (PD3(INT1/OC2B/PCINT19))
MUX_INH_2: IC3.6 (INH), IC5.6 (PD4(T0/XCK/PCINT20))
MUX_OUT: IC1.3 (X), IC2.3 (X), IC3.3 (X), R68.2
unnamed: 22_1.VCC (V+), C2.1, R3.1
unnamed: 22_1.OUT, R2.1
unnamed: 22_2.VCC (V+), C5.1, R5.1
unnamed: 22_2.OUT, R4.1
unnamed: 22_0.OUT, R13.1
unnamed: 22_3.VCC (V+), C7.1, R7.1
unnamed: 22_3.OUT, R6.1
unnamed: 22_0.VCC (V+), C4.1, R1.1
unnamed: 22_4.VCC (V+), C9.1, R9.1
unnamed: 22_4.OUT, R8.1
unnamed: 22_5.VCC (V+), C11.1, R11.1
unnamed: 22_5.OUT, R10.1
unnamed: 22_6.VCC (V+), C13.1, R14.1
unnamed: 22_6.OUT, R12.1
unnamed: 22_7.VCC (V+), C15.1, R16.1
unnamed: 22_7.OUT, R15.1
unnamed: 22_8.VCC (V+), C17.1, R18.1
unnamed: 22_8.OUT, R17.1
unnamed: 22_9.VCC (V+), C19.1, R20.1
unnamed: 22_9.OUT, R19.1
unnamed: 22_10.VCC (V+), C21.1, R22.1
unnamed: 22_10.OUT, R21.1
unnamed: 22_11.VCC (V+), C23.1, R24.1
unnamed: 22_11.OUT, R23.1
unnamed: 22_12.VCC (V+), C25.1, R26.1
unnamed: 22_12.OUT, R25.1
unnamed: 22_13.VCC (V+), C27.1, R28.1
unnamed: 22_13.OUT, R27.1
unnamed: 22_14.VCC (V+), C30.1, R30.1
unnamed: 22_14.OUT, R29.1
unnamed: 22_15.VCC (V+), C32.1, R32.1
unnamed: 22_15.OUT, R31.1
unnamed: 22_16.VCC (V+), C34.1, R34.1
unnamed: 22_16.OUT, R33.1
unnamed: 22_17.VCC (V+), C36.1, R36.1
unnamed: 22_17.OUT, R35.1
unnamed: 22_18.VCC (V+), C38.1, R38.1
unnamed: 22_18.OUT, R37.1
unnamed: 22_19.VCC (V+), C40.1, R40.1
unnamed: 22_19.OUT, R39.1
unnamed: 22_20.VCC (V+), C42.1, R42.1
unnamed: 22_20.OUT, R41.1
unnamed: 22_21.VCC (V+), C44.1, R44.1
unnamed: 22_21.OUT, R43.1
unnamed: 22_22.VCC (V+), C46.1, R46.1
unnamed: 22_22.OUT, R45.1
unnamed: 22_23.VCC (V+), C48.1, R48.1
unnamed: 22_23.OUT, R47.1
unnamed: QG1.4 (CON), R65.1
unnamed: IC5.17 (PB3(MOSI/OC2A/PCINT3)), JP2.2
unnamed: JP1.4, JP2.1
unnamed: JP2.3, SPI_CON.3
unnamed: IC5.23 (PC0(ADC0/PCINT8)), R67.2, R68.1
unnamed: R69.1, R74.1, U$1.2 (G)
unnamed: R70.1, R73.1, U$1.4 (G)
unnamed: R71.1, R76.1, U$2.4 (G)
unnamed: R72.1, R75.1, U$2.2 (G)
unnamed: IC5.2 (PD0(RXD/PCINT16)), JP3.4
unnamed: IC5.3 (PD1(TXD/PCINT17)), JP3.5
unnamed: IC5.27 (PC4(ADC4/SDA/PCINT12)), JP4.3, R77.2
unnamed: IC5.28 (PC5(ADC5/SCLPCINT13)), JP4.4, R78.2
unnamed: IC5.10 (PB7(XTAL2/TOSC2/PCINT7)), JP5.1, R79.2
unnamed: R79.1, TSOP_LED.A
RESET: C65.2, IC5.1 (PC6(/RESET/PCINT14)), JP1.5, PB_RESET.1 (S), PB_RESET.2 (S1), R66.1
SCK: IC5.19 (PB5(SCK/PCINT5)), JP1.3, SPI_CON.4
SS_TSOP_CONTROLLER: IC5.16 (PB2(SS/OC1B/PCINT2)), SPI_CON.2
SYS_CLK: IC5.9 (PB6(XTAL1/TOSC1/PCINT6)), QG1.2 (OUT)
TSOP0: C28.1, IC1.13 (X0), R13.2
TSOP1: C1.1, IC1.14 (X1), R2.2
TSOP2: C3.1, IC1.15 (X2), R4.2
TSOP3: C6.1, IC1.12 (X3), R6.2
TSOP4: C8.1, IC1.1 (X4), R8.2
TSOP5: C10.1, IC1.5 (X5), R10.2
TSOP6: C12.1, IC1.2 (X6), R12.2
TSOP7: C14.1, IC1.4 (X7), R15.2
TSOP8: C16.1, IC2.13 (X0), R17.2
TSOP9: C18.1, IC2.14 (X1), R19.2
TSOP10: C20.1, IC2.15 (X2), R21.2
TSOP11: C22.1, IC2.12 (X3), R23.2
TSOP12: C24.1, IC2.1 (X4), R25.2
TSOP13: C26.1, IC2.5 (X5), R27.2
TSOP14: C29.1, IC2.2 (X6), R29.2
TSOP15: C31.1, IC2.4 (X7), R31.2
TSOP16: C33.1, IC3.13 (X0), R33.2
TSOP17: C35.1, IC3.14 (X1), R35.2
TSOP18: C37.1, IC3.15 (X2), R37.2
TSOP19: C39.1, IC3.12 (X3), R39.2
TSOP20: C41.1, IC3.1 (X4), R41.2
TSOP21: C43.1, IC3.5 (X5), R43.2
TSOP22: C45.1, IC3.2 (X6), R45.2
TSOP23: C47.1, IC3.4 (X7), R47.2
VCC: C66.1, IC1.16 (VCC), IC2.16 (VCC), IC3.16 (VCC), IC5.7 (VCC), IC5.20 (AVCC), IC5.21 (AREF), JP1.2, JP4.2, QG1.1 (VDD), R65.2, R66.2, R69.2, R70.2, R71.2, R72.2, R77.1, R78.1, SPI_CON.5, U$1.1 (S), U$1.3 (S), U$2.1 (S), U$2.3 (S)
VTSOP_A: R1.2, R9.2, R18.2, R26.2, R34.2, R42.2, U$1.7 (D), U$1.8 (D)
VTSOP_A_ON: IC5.12 (PD6(AIN0/OC0A/PCINT22)), R74.2
VTSOP_B: R3.2, R11.2, R20.2, R28.2, R36.2, R44.2, U$1.5 (D), U$1.6 (D)
VTSOP_B_ON: IC5.13 (PD7(AIN1/PCINT23)), R73.2
VTSOP_C: R5.2, R14.2, R22.2, R30.2, R38.2, R46.2, U$2.7 (D), U$2.8 (D)
VTSOP_C_ON: IC5.14 (PB0(ICP1/CLKO/PCINT0)), R75.2
VTSOP_D: R7.2, R16.2, R24.2, R32.2, R40.2, R48.2, U$2.5 (D), U$2.6 (D)
VTSOP_D_ON: IC5.15 (PB1(OC1A/PCINT1)), R76.2

Board: 2 copper layers, 201.2 x 155.2 mm, 152 parts (20 on the bottom side), 109 nets.

## EAGLE design ec_motor_board.brd

Parts:
C1: 68nF; C1206
C2: 10nF; C1206
C3, C4: 47nF; C1206
C5: 10nF 50V; C1206
C6: 220 uF; PANASONIC_F
C7, C8, C9: 100nF; C1206
D1, D2: 1N4148 SMD; SOD80C
R1: 2,2k; R1206
R2, R3: 47k; R1206
R4: 100; R1206
R5, R8, R9: 1; R1206
R6: 15k; R1206
R7: 56k; R1206
R10, R11, R12: R-EU_R1206; R1206
R13: 0; R1206
ROW1, ROW2: PINHD-1X10; 1X10
U$1: L6235PD; PSO36

Connections:
+15V: C6.+, C7.1, C8.2, C9.1, D2.A, ROW1.1, ROW1.2, U$1.4 (VS_A), U$1.33 (VS_B)
GND: C1.1, C2.2, C3.1, C4.1, C6.-, C7.2, R2.1, R3.1, R5.2, R6.1, R8.2, R9.2, ROW1.9, ROW1.10, ROW2.10, U$1.1 (GND), U$1.18 (GND), U$1.19 (GND), U$1.36 (GND), U$1.M@1 (GND), U$1.M@2 (GND), U$1.M@3 (GND)
unnamed: ROW2.9, U$1.22 (TACHO)
unnamed: C4.2, R3.2, U$1.24 (RCPULSE)
unnamed: ROW2.2, U$1.26 (FWD/REV)
unnamed: C3.2, R2.2, U$1.13 (RCOFF)
unnamed: C2.1, R6.2, R7.2, U$1.28 (VREF)
unnamed: ROW2.3, U$1.29 (BREAK)
unnamed: R5.1, R8.1, R9.1, U$1.12 (SENSE_A), U$1.25 (SENSE_B)
unnamed: C1.2, R1.2, U$1.11 (DIAG), U$1.27 (EN)
unnamed: R4.2, U$1.7 (VCP)
unnamed: C5.2, R4.1
unnamed: C5.1, D1.A, D2.C
unnamed: C8.1, C9.2, D1.C, U$1.30 (VBOOT)
unnamed: R7.1, R13.2, ROW2.8
unnamed: ROW1.3, U$1.15 (OUT_1)
unnamed: R10.1, ROW1.4, U$1.10 (H_1)
unnamed: ROW1.5, U$1.5 (OUT_2)
unnamed: R11.2, ROW1.6, U$1.8 (H_2)
unnamed: ROW1.7, U$1.32 (OUT_3)
unnamed: R12.2, ROW1.8, U$1.9 (H_3)
unnamed: R1.1, ROW2.6
VCC: R10.2, R11.1, R12.1, R13.1, ROW2.1

Board: 2 copper layers, 28.0 x 50.0 mm, 27 parts (9 on the bottom side), 23 nets.

## EAGLE design tsop_amplifier.brd

Parts:
3V3: TPSQTP20SQ; TP20SQ
GND: TPSQTP20SQ; TP20SQ
IC1: AD8655R; SO8
IIN: TPSQTP20SQ; TP20SQ
OUT: TPSQTP20SQ; TP20SQ
R1, R4: 33k; R1206
R2, R3: 18k; R1206
R5: 1.5k; R1206
R6: 1k; R1206

Connections:
+3V3: 3V3.TP, IC1.7 (+VS), R5.2
GND: GND.TP, IC1.4 (-VS), R4.1, R6.1
IN: IIN.TP, R3.1
unnamed: IC1.3 (IN+), R1.1, R2.2
unnamed: IC1.2 (IN-), R3.2, R4.2
unnamed: R2.1, R5.1, R6.2
OUT: IC1.6 (OUT), OUT.TP, R1.2

Notes on the sheet:
1.4V - 3.2V
0 - 3.3V
~1.4V

Board: 2 copper layers, 14.2 x 14.9 mm, 11 parts (4 on the bottom side), 7 nets.

## EAGLE design interface_us_board.brd

Parts:
C1, C2, C3, C4, C8, C11, C12: 100nF; C1206
C9, C10, C42, C43, C44, C45, C46, C47, C48: 1µF; C1206
IC1: 74AC245DW; SO20W
IC2: 4050D; SO16
PB_RESET: 10-XX; B3F-10XX; MPN B3F-1000
PB_RETURN: 10-XX; B3F-10XX; MPN B3F-1000
R1, R7, R8: 47; M1206
R2, R3, R5, R28: 0; M1206
R4, R6: 0; R1206
SV1, SV2: ML10
SV5: ML20
U$1: JMT-4130
U$3: EA_DOG-M_DISPLAY; E_DOG-M_DISPLAY
US_BACK: SRF05/90; SRF05
US_FRONT: SRF05/90; SRF05
US_LEFT: SRF05/90; SRF05
US_RIGHT: SRF05/90; SRF05

Connections:
+5V: IC1.20 (VCC), R6.1, SV1.2, US_BACK.5 (VCC), US_FRONT.5 (VCC), US_LEFT.5 (VCC), US_RIGHT.5 (VCC)
A0-LCD: SV5.5, U$3.38 (A0)
BACKL+_1: R1.2, U$3.1 (A1)
BACKL+_2: R7.2, U$3.2 (A2)
BACKL+_3: R8.2, U$3.3 (A3)
CTS_BLUETOOTH: SV2.2, SV5.6
DOWN: C8.1, SV5.16, U$1.DOWN_6
ENTER: C11.2, SV5.10, U$1.PUSH_3
GND: C1.1, C2.2, C3.1, C4.1, C8.2, C11.1, C12.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, IC1.10 (GND), IC2.8 (VSS), PB_RESET.3, PB_RESET.4 (P1), PB_RETURN.3, PB_RETURN.4 (P1), R2.2, R3.2, R4.1, R5.2, R28.2, SV1.1, SV2.7, SV2.9, SV5.17, U$1.CENTER_1, U$3.18 (C1), U$3.19 (C2), U$3.20 (C3), U$3.26 (VSS), U$3.33 (VSS2), US_BACK.1 (GND), US_FRONT.1 (GND), US_LEFT.1 (GND), US_RIGHT.1 (GND)
LCD-RST: SV5.3, U$3.39 (RST)
LEFT: C12.1, SV5.14, U$1.LEFT_2
MOSI: SV5.13, U$3.36 (SI)
unnamed: IC2.3 (I), US_BACK.4 (ECHO/TRIGGER)
unnamed: IC1.14 (B5), US_FRONT.3 (TRIGGER)
unnamed: R28.1, US_BACK.2 (MODE)
unnamed: IC1.12 (B7), US_RIGHT.3 (TRIGGER)
unnamed: IC1.1 (DIR), R6.2
unnamed: IC1.18 (B1), US_BACK.3 (TRIGGER)
unnamed: IC1.19 (G), R4.2
unnamed: IC1.16 (B3), US_LEFT.3 (TRIGGER)
unnamed: R5.1, US_LEFT.2 (MODE)
unnamed: R2.1, US_FRONT.2 (MODE)
unnamed: C9.1, U$3.27 (CAP2N)
unnamed: C9.2, U$3.28 (CAP2P)
unnamed: R3.1, US_RIGHT.2 (MODE)
unnamed: IC2.9 (I), US_RIGHT.4 (ECHO/TRIGGER)
unnamed: IC2.7 (I), US_FRONT.4 (ECHO/TRIGGER)
unnamed: IC2.5 (I), US_LEFT.4 (ECHO/TRIGGER)
unnamed: C10.1, U$3.29 (CAP1P)
unnamed: C10.2, C42.2, U$3.30 (CAP1N)
unnamed: C44.1, U$3.22 (V1)
unnamed: C42.1, U$3.31 (CAP3P)
unnamed: C46.1, U$3.24 (V3)
unnamed: C43.1, U$3.21 (V0)
unnamed: C45.1, U$3.23 (V2)
unnamed: C47.1, U$3.25 (V4)
unnamed: C48.1, U$3.32 (VOUT)
RESET_COM: C4.2, PB_RESET.1 (S), PB_RESET.2 (S1), SV5.15
RETURN: C3.2, PB_RETURN.1 (S), PB_RETURN.2 (S1), SV5.12
RIGHT: C1.2, SV5.18, U$1.RIGHT_5
RTS_BLUETOOTH: SV2.5, SV5.8
RX_BLUETOOTH: SV2.3, SV5.2
SCK: SV5.1, U$3.37 (SCL)
SCL: SV2.6, SV5.9
SDA: SV2.4, SV5.11
SS-LCD: SV5.7, U$3.40 (CS1B)
TX_BLUETOOTH: SV2.1, SV5.4
UP: C2.1, SV5.20, U$1.UP_4
US_BACK_ECHO: IC2.2 (O), SV1.5
US_BACK_TRIG: IC1.2 (A1), SV1.10
US_FRONT_ECHO: IC2.6 (O), SV1.9
US_FRONT_TRIG: IC1.6 (A5), SV1.6
US_LEFT_ECHO: IC2.4 (O), SV1.3
US_LEFT_TRIG: IC1.4 (A3), SV1.8
US_RIGHT_ECHO: IC2.10 (O), SV1.7
US_RIGHT_TRIG: IC1.8 (A7), SV1.4
VCC: IC2.1 (VDD), R1.1, R7.1, R8.1, SV2.8, SV2.10, SV5.19, U$3.34 (VDD2), U$3.35 (VDD)

Notes on the sheet:
3.3 -> 5V
3.3 <- 5V
from Mainboard
to Compass and Bluetooth

Board: 2 copper layers, 160.0 x 107.8 mm, 38 parts (23 on the bottom side), 57 nets.

## EAGLE design motor_board.brd

Parts:
C1: 220 uF; PANASONIC_F
C2: 33nF; C1206
C4: 100nF; C1206
DRA: VNH5019A; MULTIPOWERSO-30
JP1, JP2: PINHD-1X10; 1X10
R1, R2, R3, R4, R5, R9, R11: 1k; R1206
R6, R7, R8: 4.7k; R1206
R10: 10k; R1206
U$1: IRF7413; SO8-2

Connections:
+15V: DRA.12 (VBAT), JP2.1, JP2.2, U$1.1 (S), U$1.2 (S1), U$1.3 (S2)
ADC1_IN10: C2.2, JP1.7, R10.1
AGND: C1.-, C4.2, DRA.18 (GNDB), DRA.19 (GNDB), DRA.20 (GNDB), DRA.26 (GNDA), DRA.27 (GNDA), DRA.28 (GNDA), JP2.9, JP2.10
GND: C2.1, JP1.10, R8.2, R9.1, R11.1
MOTOR_A_+: DRA.1 (OUTA), DRA.25 (OUTA), DRA.30 (OUTA), DRA.OUTA, DRA.OUTA@1 (OUTA), JP2.3
MOTOR_A_-: DRA.15 (OUTB), DRA.16 (OUTB), DRA.21 (OUTB), DRA.OUTB, DRA.OUTB@1 (OUTB), JP2.7
MOTOR_A_DIAGA_: DRA.5 (DIAGA), R3.2, R6.2
MOTOR_A_DIAGB_: DRA.9 (DIAGB), R4.2, R7.2
MOTOR_A_INA: DRA.4 (INA), R1.2
MOTOR_A_INB: DRA.10 (INB), R2.2
MOTOR_A_OUTA: JP1.2, R1.1
MOTOR_A_OUTB: JP1.3, R2.1
MOTOR_A_PWM: DRA.7 (PWM), R5.2
unnamed: DRA.11 (CP), U$1.4 (G)
unnamed: C1.+, C4.1, DRA.3 (VCC), DRA.13 (VCC), DRA.23 (VCC), DRA.VCC, DRA.VCC@1 (VCC), U$1.5 (D3), U$1.6 (D2), U$1.7 (D1), U$1.8 (D0)
unnamed: DRA.6 (CS_DIS), R9.2
unnamed: DRA.8 (CS), R10.2, R11.2
PB3_IN: JP1.5, R4.1
PD2_IN: JP1.4, R3.1
TIM5_PWM1: JP1.6, R5.1, R8.1
VCC: JP1.1, R6.1, R7.1

Board: 2 copper layers, 28.0 x 50.0 mm, 18 parts (0 on the bottom side), 21 nets.

## EAGLE design motor_adapter_right.brd

Parts:
R1, R2: 10k; R1206
SV1, SV3: ML6
SV2: ML14
X1, X2: MSTBA2

Connections:
+5V: SV1.4, SV2.1, SV3.4
GND: R1.2, R2.1, SV1.3, SV2.2, SV3.3
MOTOR_A_+: SV1.2, SV2.14
MOTOR_A_-: SV1.1, SV2.6
MOTOR_A_CHANNEL_A: SV1.6, SV2.12
MOTOR_A_CHANNEL_B: SV1.5, SV2.4
MOTOR_C_+: SV2.3, SV3.2
MOTOR_C_-: SV2.11, SV3.1
MOTOR_C_CHANNEL_A: SV2.5, SV3.6
MOTOR_C_CHANNEL_B: SV2.13, SV3.5
unnamed: R2.2, SV2.8
unnamed: R1.1, SV2.9
unnamed: X1.1, X2.1
unnamed: X1.2, X2.2
